# Keil uVision project BoardDemo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: FT32F072RBATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: dd +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\USER\Include;.\TOUCH_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group USER
    ./USER/Source/: ft32f0xx_it.c main.c
  group Lib
    ./TOUCH_LIB/: ft32f0xx_touch_intscan_fs_cs.lib
software components: CMSIS:CORE 5.5.0, Device:FT32Driver:COMMON 1.0.1, Device:FT32Driver:COMP 1.0.1, Device:FT32Driver:DMA 1.0.1, Device:FT32Driver:EXTI 1.0.1, Device:FT32Driver:FLASH 1.0.1, Device:FT32Driver:GPIO 1.0.1, Device:FT32Driver:MISC 1.0.1, Device:FT32Driver:RCC 1.0.1, Device:FT32Driver:TIM 1.0.1, Device:FT32Driver:USART 1.0.1, Device:Startup 1.0.1
