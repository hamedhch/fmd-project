# IAR project Pro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\USER\Include; ..\TOUCH_LIB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: Pro.srec
  ILINK.IlinkOutputFile: Pro.out
  ILINK.IlinkAdditionalLibs: ..\TOUCH_LIB\ft32f0xx_touch_pollscan_fs_cs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/FMD StdDriverOne _Device.Startup_1.0.1
    RTE/Device/FT32F072R8ATx/: system_ft32f0xx.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.RCC_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.2}$/Drivers/FT32F0xx_Driver/Src/: ft32f0xx_rcc.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.GPIO_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.2}$/Drivers/FT32F0xx_Driver/Src/: ft32f0xx_gpio.c
  group USER
    ../USER/Source/: board.c ft32f0xx_it.c main.c
    ../Startup/: startup_FT32f072.s
